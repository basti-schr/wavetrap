options:
  parameters:
    author: Sebastian Schröder
    generate_options: qt_gui
    id: testCtlToggleSwitch
    output_language: python
    title: Test CtlToggleSwitch
  states: {}

blocks:
- name: variable_qtgui_toggle_switch_0
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: wavetrap_CtlToggleButton_0
  id: wavetrap_CtlToggleButton
  parameters:
    initPressed: 'False'
    label: ''
    outputmsgname: value
    pressBackgroundColor: default
    pressFontColor: default
    pressed: '1'
    relBackgroundColor: default
    relFontColor: default
    released: '0'
    type: int
    value: '0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters: {}
  states: {}

connections:
- [variable_qtgui_toggle_switch_0, state, blocks_message_debug_0, log]
- [variable_qtgui_toggle_switch_0, state, wavetrap_CtlToggleButton_0, set_state]
- [wavetrap_CtlToggleButton_0, state, blocks_message_debug_0, log]
- [wavetrap_CtlToggleButton_0, state, qtgui_ledindicator_0, state]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
