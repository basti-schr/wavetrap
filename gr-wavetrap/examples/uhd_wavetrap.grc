options:
  parameters:
    author: Muad'Dib
    generate_options: qt_gui
    id: uhd_wavetrap
    output_language: python
    title: WAVETRAP PUSH-BUTTON RF RECORDER
  states: {}

blocks:
- name: duration
  id: variable_qtgui_entry
  parameters:
    gui_hint: tabs@0:1,2,1,1
    label: Duration [s]
    type: real
    value: '1'
  states: {}
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to IQ recording
      and adds timestamp and the 
      'note' variable to the filename
    value: rootdir+record_file_path+note+"_"+str(int(freq))+"Hz_"+str(int(gui_samp_rate))+"sps_"
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,2,1,1
    label: Center Frequency
    start: 50e6
    step: 10e3
    stop: 6e9
    value: 1575.42e6
    widget: eng_slider
  states: {}
- name: gui_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,1
    label: RX Gain
    start: '0'
    step: '1'
    stop: '76'
    value: rf_gain
  states: {}
- name: gui_samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,1,1,1
    label: Sample Rate
    min_len: '10'
    start: 200e3
    step: 1e6
    stop: 56e6
    value: samp_rate
    widget: eng
  states: {}
- name: note
  id: variable_qtgui_entry
  parameters:
    gui_hint: tabs@0:1,0,1,2
    label: RECORDING NOTE (press enter to update)
    type: string
    value: RECORDING_NOTE
  states: {}
- name: rec_button
  id: wavetrap_CtlToggleButton
  parameters:
    gui_hint: tabs@0:1,3,1,1
    initPressed: 'False'
    label: ''
    outputmsgname: value
    pressBackgroundColor: default
    pressFontColor: default
    pressed: '1'
    relBackgroundColor: default
    relFontColor: default
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: set path to IQ recording directory
    value: '"data/"'
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: |-
      Add directory in quotes with trailing and leading /:
      like: "/media/user/GNNS-R/"
    value: '"/home/sebastian/Software/gnssr-test/Gloshaugen/"'
  states: {state: disabled}
- name: rootdir
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: str(os.path.expanduser("~")+"/")
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: |-
      defaults to your temporary /tmp directory
      used for testing
    value: '"/tmp/"'
  states: {state: disabled}
- name: samples
  id: variable
  parameters:
    value: int(duration * gui_samp_rate)
  states: {}
- name: timestamp
  id: variable
  parameters:
    comment: |-
      gets system time and
      applies string formatting
    value: datetime.fromtimestamp(time.time()).strftime('%Y-%m-%d_%H-%M-%S')
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq/4
    offset: '0'
    phase: '0'
    samp_rate: gui_samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq/4
    offset: '0'
    phase: '0'
    samp_rate: gui_samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S'))+"_RF0.raw" if rec_button == 1 else "/dev/null"
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: filename+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S'))+"_RF1.raw" if rec_button == 1 else "/dev/null"
    type: complex
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freq
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\nfrom datetime import datetime\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Control logic',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        \n        self.message_port_register_out(pmt.intern('msg_out'))\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n \n    def handle_msg(self, msg):\n        val =  pmt.to_python(msg)\n        print(val)\n        if val=='FINISHED':\n            self.message_port_pub(pmt.intern(\"msg_out\"), pmt.cons(pmt.intern(\"value\"), pmt.from_bool(False)))\n        elif val=='IN PROGRESS':\n            pass\n        elif val=='RESET':\n            pass\n        \n\n\n\n\n"
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    comment: If you have OpenCL Support on you plattform this Sink can ce used
    freq_center: freq
    freq_span: gui_samp_rate
    gui_hint: tabs@0:2,0,5,4
  states: {state: disabled}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: tabs@0:0,3,1,1
    label: '"RED=RECORDING"'
    offColor: green
    onColor: red
    position: '2'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: gui_samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: tabs@0:2,0,2,2
    name: '"RF 0"'
    plotconst: 'False'
    rate: '20'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: gui_samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: tabs@0:2,2,2,2
    name: '"RF 1"'
    plotconst: 'False'
    rate: '20'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: rf_bw
  id: parameter
  parameters:
    label: RF BANDWITDH
    short_id: b
    type: eng_float
    value: 20e6
  states: {state: disabled}
- name: rf_freq
  id: parameter
  parameters:
    label: RF FREQUENCY
    short_id: f
    type: eng_float
    value: 1575.42e6
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF GAIN
    short_id: g
    type: eng_float
    value: '70'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: SAMPLE RATE
    short_id: s
    type: eng_float
    value: 4e6
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,7,4
    label0: RF Settings
    num_tabs: '1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: gui_samp_rate
    bw1: gui_samp_rate
    center_freq0: freq
    center_freq1: '0'
    clock_source0: internal
    gain0: gui_gain
    gain1: gui_gain
    nchan: '2'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: gui_samp_rate
    sync: none
    type: fc32
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Reset freq to L1
    msgName: freq
    type: real
    value: 1575.42e6
  states: {state: disabled}
- name: wavetrap_head_w_rst_0
  id: wavetrap_head_w_rst
  parameters:
    dump_buff: 'True'
    num_items: samples
    type: complex
    vlen: '2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_streams_to_vector_0, '0']
- [analog_sig_source_x_0, '0', qtgui_sink_x_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_streams_to_vector_0, '1']
- [analog_sig_source_x_0_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_streams_to_vector_0, '0', wavetrap_head_w_rst_0, '0']
- [blocks_var_to_msg_0, msgout, qtgui_sink_x_0, freq]
- [blocks_var_to_msg_0, msgout, qtgui_sink_x_0_0, freq]
- [blocks_vector_to_streams_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_file_sink_0_0, '0']
- [epy_block_0, msg_out, rec_button, set_state]
- [rec_button, state, qtgui_ledindicator_0, state]
- [rec_button, state, wavetrap_head_w_rst_0, reset]
- [uhd_usrp_source_0, '0', blocks_streams_to_vector_0, '0']
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_streams_to_vector_0, '1']
- [uhd_usrp_source_0, '1', qtgui_sink_x_0_0, '0']
- [variable_qtgui_msg_push_button_0, pressed, blocks_msgpair_to_var_0, inpair]
- [wavetrap_head_w_rst_0, '0', blocks_vector_to_streams_0, '0']
- [wavetrap_head_w_rst_0, status, epy_block_0, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
